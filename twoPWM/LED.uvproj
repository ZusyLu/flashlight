# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F570200 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group User
    ./: OPTIONS_SN8F5702.A51
    ./Inc/: common.h delay.h
    ./Src/: main.c
    ./src/: delay.c
